<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\BLUE_PILL-STM32F103_1.ewp</path>
  </project>
  <batchBuild />
</workspace>
